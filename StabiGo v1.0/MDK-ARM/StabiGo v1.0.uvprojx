# Keil uVision project StabiGo v1.0.uvprojx, settings and files
target StabiGo v1.0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: StabiGo v1_0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../App;../Module;../Dev;../Drv;..\Os
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group App
    ../App/: Board.c
  group Drv
    ../Drv/: DrvI2cSw.c DrvUsDelay.c DrvTimeStamp.c
  group Dev
    ../Dev/: DevSsd1315.c
  group Os
    ../Os/: tiny_eds.c
software components: CMSIS:CORE 5.4.0
